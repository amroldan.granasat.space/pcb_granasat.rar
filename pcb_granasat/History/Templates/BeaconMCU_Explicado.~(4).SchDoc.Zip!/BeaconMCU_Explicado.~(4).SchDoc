# Altium schematic sheet BeaconMCU_Explicado.~(4).SchDoc
size A4

## Notes on the sheet
- Beacon MCU: Explicación
- 5
- JF & Antonio