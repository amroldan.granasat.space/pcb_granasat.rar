# Altium schematic sheet BeaconMCU_Explicado.~(5).SchDoc
size A4

## Notes on the sheet
- Beacon MCU: Explicación
- 5
- 11
- JF & Antonio