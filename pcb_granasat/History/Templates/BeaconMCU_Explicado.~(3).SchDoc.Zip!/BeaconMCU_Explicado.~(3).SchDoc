# Altium schematic sheet BeaconMCU_Explicado.~(3).SchDoc
size A4

## Notes on the sheet
- 4
- JF & Antonio